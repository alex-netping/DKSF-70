# IAR project DKSF_70.ewp, settings and files
configuration RAM Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR_LPC_1768_SK
  ICCARM.CCIncludePath2: $PROJ_DIR$; DEF
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DKSF_70.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config\dksf70.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Flash Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1778 NXP LPC1778
  ICCARM.CCIncludePath2: $PROJ_DIR$; DEF
  OBJCOPY.OOCOutputFile: DKSF_70.srec
  group (top)
    ./: cstartup_M.s eeprom_map.h html_data.c main.c mib_tree.c platform_setup.h project.c sys.c system_event.c
  group DEF
    DEF/: crc_def.h cur_det_def.h delay_def.h dns_def.h flash_lpc_def.h http2_def.h hw_i2c_def.h icmp_def.h io_def.h ip_def.h ir2_def.h led_def.h LOG_def.h logic_def.h mac236x_def.h nic_def.h ntp_def.h phy_def.h ping_def.h project_def.h pwr2_def.h relay_uniping_def.h relhum_def.h rtc_def.h sendmail_def.h sms_def.h snmp_def.h snmp_setter_def.h spi_eeprom_def.h sw_i2c_def.h tcp_def.h tcpcom_def.h termo_def.h uart_def.h udp_def.h watchdog_def.h wtimer_def.h
  group MODULES
    CRC/: crc.c
    CUR_DET/: cur_det.c
    DELAY/: delay.c
    DNS/: dns.c
    FLASH_LPC/: flash_lpc.c
    HTTP2/: http2.c
    HW_I2C/: hw_i2c.c
    ICMP/: icmp.c
    IO2/: io.c
    IP/: ip3.c
    IR2/: ir.c
    LED/: LED.c
    LOG/: LOG.c
    LOGIC2/: logic.c
    MAC236X/: mac236x.c
    NIC/: nic.c
    NOTIFY/: notify.c
    NTP/: NTP.c
    OW/: ow.c
    PHY/: phy_KSZ8863.c
    PING/: ping.c
    RELAY/: relay_uniping.c
    RELHUM/: relhum2.c
    RTC/: rtc.c
    SENDMAIL/: sendmail.c
    SMS/: sms.c sms_cmd.c
    SNMP/: snmp.c
    SNMP_SETTER/: snmp_setter.c
    SPI_EEPROM/: spi_eeprom.c
    STR/: str2.c
    SW_I2C/: sw_i2c.c
    TCP/: tcp.c
    TCPCOM/: tcpcom.c
    TERMO/: TERMO.c
    UART/: uart.c
    UDP/: udp.c
    WATCHDOG/: watchdog.c
    WTIMER/: wtimer.c
